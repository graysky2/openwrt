// SPDX-License-Identifier: GPL-2.0-or-later
/dts-v1/;

#include "rtl9302_ubnt_usw-pro-max-common.dtsi"

#include <dt-bindings/leds/common.h>

/* ADT7475 temperature sensors: */
/* temp1: Q9 under RTL9302B SoC heatsink */
/* temp2: Local ADT sensor under RTL8224 heatsink */
/* temp3: Q10 near SFP cages */

/ {
	compatible = "ubnt,usw-pro-max-16-poe", "realtek,rtl9302b-soc";
	model = "UniFi USW Pro Max 16 PoE";
};

&i2c4 {
	#address-cells = <1>;
	#size-cells = <0>;

	etherlight@66 {
		compatible = "ubnt,etherlighting";
		reg = <0x66>;
		#address-cells = <1>;
		#size-cells = <0>;

		/* MCU index N is front port N+1; SFP+ cages not mapped yet */
		led@0 {
			reg = <0>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <1>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@1 {
			reg = <1>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <2>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@2 {
			reg = <2>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <3>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@3 {
			reg = <3>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <4>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@4 {
			reg = <4>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <5>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@5 {
			reg = <5>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <6>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@6 {
			reg = <6>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <7>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@7 {
			reg = <7>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <8>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@8 {
			reg = <8>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <9>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@9 {
			reg = <9>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <10>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@10 {
			reg = <10>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <11>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@11 {
			reg = <11>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <12>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@12 {
			reg = <12>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <13>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@13 {
			reg = <13>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <14>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@14 {
			reg = <14>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <15>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};

		led@15 {
			reg = <15>;
			color = <LED_COLOR_ID_MULTI>;
			function = LED_FUNCTION_LAN;
			function-enumerator = <16>;
			#address-cells = <1>;
			#size-cells = <0>;

			led@0 { reg = <0>; color = <LED_COLOR_ID_RED>; };
			led@1 { reg = <1>; color = <LED_COLOR_ID_GREEN>; };
			led@2 { reg = <2>; color = <LED_COLOR_ID_BLUE>; };
			led@3 { reg = <3>; color = <LED_COLOR_ID_WHITE>; };
		};
	};
};

&pse {
	compatible = "ubnt,usw-pro-max-16-poe-pse", "realtek,pse-mcu-gen2-smbus";

	pse-pis {
		PSE_PI(0)
		PSE_PI(1)
		PSE_PI(2)
		PSE_PI(3)
		PSE_PI(4)
		PSE_PI(5)
		PSE_PI(6)
		PSE_PI(7)
		PSE_PI(8)
		PSE_PI(9)
		PSE_PI(10)
		PSE_PI(11)
		PSE_PI(12)
		PSE_PI(13)
		PSE_PI(14)
		PSE_PI(15)
	};
};

&mdio_bus2 {
	/* RTL8224 */
	ethernet-phy-package@0 {
		reg = <0>;
		#address-cells = <1>;
		#size-cells = <0>;

		PHY_C45(20, 0)
		PHY_C45(21, 1)
		PHY_C45(22, 2)
		PHY_C45(23, 3)
	};
};

&switch0 {
	ethernet-ports {
		SWITCH_PORT_LED(0, 1, 2, 0, 0, usxgmii)
		SWITCH_PORT_LED(1, 2, 2, 1, 0, usxgmii)
		SWITCH_PORT_LED(2, 3, 2, 2, 0, usxgmii)
		SWITCH_PORT_LED(3, 4, 2, 3, 0, usxgmii)
		SWITCH_PORT_LED(4, 5, 2, 4, 0, usxgmii)
		SWITCH_PORT_LED(5, 6, 2, 5, 0, usxgmii)
		SWITCH_PORT_LED(6, 7, 2, 6, 0, usxgmii)
		SWITCH_PORT_LED(7, 8, 2, 7, 0, usxgmii)

		/* 8, 9, 14, 15 Unconnected ports, required for PHY initialization */
		port@8 {
			reg = <8>;
			label = "nc1";
			led-set = <0>;
			pcs-handle = <&serdes3 0>;
			phy-handle = <&phy8>;
			phy-mode = "usxgmii";
		};

		port@9 {
			reg = <9>;
			label = "nc2";
			led-set = <0>;
			pcs-handle = <&serdes3 1>;
			phy-handle = <&phy9>;
			phy-mode = "usxgmii";
		};

		SWITCH_PORT_LED(10, 9, 3, 2, 0, usxgmii)
		SWITCH_PORT_LED(11, 10, 3, 3, 0, usxgmii)
		SWITCH_PORT_LED(12, 11, 3, 4, 0, usxgmii)
		SWITCH_PORT_LED(13, 12, 3, 5, 0, usxgmii)

		port@14 {
			reg = <14>;
			label = "nc3";
			led-set = <0>;
			pcs-handle = <&serdes3 6>;
			phy-handle = <&phy14>;
			phy-mode = "usxgmii";
		};

		port@15 {
			reg = <15>;
			label = "nc4";
			led-set = <0>;
			pcs-handle = <&serdes3 7>;
			phy-handle = <&phy15>;
			phy-mode = "usxgmii";
		};

		SWITCH_PORT_LED(20, 13, 5, 0, 0, 10g-qxgmii)
		SWITCH_PORT_LED(21, 14, 5, 1, 0, 10g-qxgmii)
		SWITCH_PORT_LED(22, 15, 5, 2, 0, 10g-qxgmii)
		SWITCH_PORT_LED(23, 16, 5, 3, 0, 10g-qxgmii)

		SWITCH_PORT_SFP(24, 17, 6, 0, 1)
		SWITCH_PORT_SFP(25, 18, 7, 0, 2)
	};
};

&phy0 { pses = <&pse_pi0>; };
&phy1 { pses = <&pse_pi1>; };
&phy2 { pses = <&pse_pi2>; };
&phy3 { pses = <&pse_pi3>; };
&phy4 { pses = <&pse_pi4>; };
&phy5 { pses = <&pse_pi5>; };
&phy6 { pses = <&pse_pi6>; };
&phy7 { pses = <&pse_pi7>; };

&phy10 { pses = <&pse_pi8>; };
&phy11 { pses = <&pse_pi9>; };
&phy12 { pses = <&pse_pi10>; };
&phy13 { pses = <&pse_pi11>; };

&phy20 { pses = <&pse_pi12>; };
&phy21 { pses = <&pse_pi13>; };
&phy22 { pses = <&pse_pi14>; };
&phy23 { pses = <&pse_pi15>; };
